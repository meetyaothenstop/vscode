# Keil uVision project unified_compare.uvprojx, settings and files
target unified_compare (6180000::V6.18::ARMCLANG)
  device: STM32G474CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: bidreaction_unified_compare +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32G474xx,POWER_BENCH_12V_BUCK_TEST=1,POWER_OCP_WIRING_CONFIRMED=0,POWER_TEST_SKIP_OLED_ACTIVE=1
  c include: C:\Users\k\Desktop\keil\hal\bidreaction\Core\Inc;C:\Users\k\Desktop\keil\hal\bidreaction\Drivers\STM32G4xx_HAL_Driver\Inc;C:\Users\k\Desktop\keil\hal\bidreaction\Drivers\STM32G4xx_HAL_Driver\Inc\Legacy;C:\Users\k\Desktop\keil\hal\bidreaction\Drivers\CMSIS\Device\ST\STM32G4xx\Include;C:\Users\k\Desktop\keil\hal\bidreaction\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    C:/Users/k/Desktop/keil/hal/bidreaction/MDK-ARM/: startup_stm32g474xx.s
  group Application/User/Core
    C:/Users/k/Desktop/keil/hal/bidreaction/Core/Src/: main.c stm32g4xx_it.c stm32g4xx_hal_msp.c key.c OLED_IIC_Config.c OLED_Function.c forward.c reverse.c adc_acquire.c adc_measure.c pwm_plan.c power_control.c power_protection.c power_menu.c power_ui.c
    C:/Users/k/Desktop/keil/hal/bidreaction/Core/Inc/: key.h OLED_IIC_Config.h OLED_Function.h OLED_Front.h forward.h reverse.h power_protection.h adc_acquire.h adc_measure.h
  group Drivers/STM32G4xx_HAL_Driver
    C:/Users/k/Desktop/keil/hal/bidreaction/Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_comp.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_hrtim.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    C:/Users/k/Desktop/keil/hal/bidreaction/Core/Src/: system_stm32g4xx.c
software components: CMSIS:CORE 6.2.0
